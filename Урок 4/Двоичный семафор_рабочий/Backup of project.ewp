# IAR project Backup of project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; inc; src; system; FreeRTOS\inc; FreeRTOS\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group FreeRTOS/inc
    FreeRTOS/inc/: croutine.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h
  group FreeRTOS/src
    FreeRTOS/src/: croutine.c event_groups.c list.c port.c portasm.s queue.c tasks.c timers.c
  group FreeRTOS/src/Mem
    FreeRTOS/src/: heap_2.c
  group inc
    inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h
  group src
    src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
  group system
    system/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h flash_config.h main.h startup_stm32f4xx.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_gpio.h system_stm32f4xx.c system_stm32f4xx.h
